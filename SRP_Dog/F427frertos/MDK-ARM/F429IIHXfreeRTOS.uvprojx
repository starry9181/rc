# Keil uVision project F429IIHXfreeRTOS.uvprojx, settings and files
target F429IIHXfreeRTOS (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F429IIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: F429IIHXfreeRTOS +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx
  c include: ../Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS; ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F; ../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../Drivers/CMSIS/Include; ..\..\User\bsp\inc; ..\..\User\app\inc; ..\..\User\drivers\counters\inc; ..\..\User\drivers\data_structure\inc; ..\..\User\drivers\modules\inc; ..\..\User\task\inc; ..\Drivers\CMSIS\DSP\Include; ..\tarsrc\Config; ..\tarsrc\Sample\Config; ..\tarsrc\Sample\Patch; ..\tarsrc\SEGGER; ..\tarsrc; ..\tarsrc\Config; ..\tarsrc\Sample
  asm include: ..\\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f429xx.s
  group Application/User
    ../Src/: main.c freertos.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_can.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group user/bsp
    ../../User/bsp/src/: bsp_can.c bsp_usart.c baseclass.c
  group user/drivers
    ../../User/drivers/modules/src/: hmi_usart.c bluetooth.c communicate.c currentmeter.c DJI_dbus.c enconder.c gyro.c laser_ranging.c leds_tip.c motor.c pc_data.c ultrasonic.c usart_debug.c wholepositioning.c fps.c Servo.c
    ../../User/drivers/counters/src/: counters.c motion_model.c power_buffer_pool.c filter.c check.c delay.c
    ../../User/drivers/data_structure/src/: DataStructure.c
    ../../User/drivers/modules/inc/: fps.h input_sw.h hmi_usart.h
    ../../User/drivers/counters/inc/: filter.h
  group user/app
    ../../User/app/src/: parse.c dog_control.c
    ../../User/app/inc/: app.h dog_control.h
  group user/task
    ../../User/task/src/: debug_by_keil.c sys_task.c use_times.c user.c
software components: CMSIS:CORE 4.3.0
